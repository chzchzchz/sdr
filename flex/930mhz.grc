<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>flex_930mhz_block</value></param>
<param><key>category</key><value>FLEX</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>930mhz block</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>base_freq</value></param>
<param><key>value</key><value>930*1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2048000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>chan/929.665e6.out</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>chan/929.614e6.out</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>file</key><value>chan/929.890e6.out</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0</value></param>
<param><key>file</key><value>chan/929.940e6.out</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_0</value></param>
<param><key>file</key><value>chan/929.989e6.out</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>930.254e6.out</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>930.204e6.out</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>930.276e6.out</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>930.226e6.out</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_1</value></param>
<param><key>file</key><value>chan/929.715e6.out</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>flex_channel</key>
<param><key>id</key><value>flex_channel_0</value></param>
<param><key>base_freq</key><value>base_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sig_freq</key><value>929.665e6</value></param>
<param><key>taps</key><value>8</value></param>
<param><key>tau</key><value>8e-6</value></param>
</block>
<block>
<key>flex_channel</key>
<param><key>id</key><value>flex_channel_0_0</value></param>
<param><key>base_freq</key><value>base_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sig_freq</key><value>929.614e6</value></param>
<param><key>taps</key><value>10</value></param>
<param><key>tau</key><value>7.8e-6</value></param>
</block>
<block>
<key>flex_channel</key>
<param><key>id</key><value>flex_channel_0_0_0</value></param>
<param><key>base_freq</key><value>base_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sig_freq</key><value>929.890e6</value></param>
<param><key>taps</key><value>8</value></param>
<param><key>tau</key><value>8e-6</value></param>
</block>
<block>
<key>flex_channel</key>
<param><key>id</key><value>flex_channel_0_0_0_0</value></param>
<param><key>base_freq</key><value>base_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sig_freq</key><value>929.940e6</value></param>
<param><key>taps</key><value>8</value></param>
<param><key>tau</key><value>8e-6</value></param>
</block>
<block>
<key>flex_channel</key>
<param><key>id</key><value>flex_channel_0_0_0_0_0</value></param>
<param><key>base_freq</key><value>base_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sig_freq</key><value>929.989e6</value></param>
<param><key>taps</key><value>8</value></param>
<param><key>tau</key><value>8e-6</value></param>
</block>
<block>
<key>flex_channel</key>
<param><key>id</key><value>flex_channel_0_0_0_0_0_0</value></param>
<param><key>base_freq</key><value>base_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sig_freq</key><value>930.254e6</value></param>
<param><key>taps</key><value>8</value></param>
<param><key>tau</key><value>8e-6</value></param>
</block>
<block>
<key>flex_channel</key>
<param><key>id</key><value>flex_channel_0_0_0_0_0_0_0</value></param>
<param><key>base_freq</key><value>base_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sig_freq</key><value>930.204e6</value></param>
<param><key>taps</key><value>8</value></param>
<param><key>tau</key><value>8e-6</value></param>
</block>
<block>
<key>flex_channel</key>
<param><key>id</key><value>flex_channel_0_0_0_0_0_0_1</value></param>
<param><key>base_freq</key><value>base_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sig_freq</key><value>930.276e6</value></param>
<param><key>taps</key><value>8</value></param>
<param><key>tau</key><value>8e-6</value></param>
</block>
<block>
<key>flex_channel</key>
<param><key>id</key><value>flex_channel_0_0_0_0_0_0_1_0</value></param>
<param><key>base_freq</key><value>base_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sig_freq</key><value>930.226e6</value></param>
<param><key>taps</key><value>8</value></param>
<param><key>tau</key><value>8e-6</value></param>
</block>
<block>
<key>flex_channel</key>
<param><key>id</key><value>flex_channel_0_0_0_0_1</value></param>
<param><key>base_freq</key><value>base_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sig_freq</key><value>929.715e6</value></param>
<param><key>taps</key><value>8</value></param>
<param><key>tau</key><value>8e-6</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>flex_channel_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>flex_channel_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>flex_channel_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>flex_channel_0_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>flex_channel_0_0_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>flex_channel_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>flex_channel_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>flex_channel_0_0_0_0_0_0_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>flex_channel_0_0_0_0_0_0_1_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>flex_channel_0_0_0_0_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>flex_channel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>flex_channel_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>flex_channel_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>flex_channel_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>flex_channel_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>flex_channel_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>flex_channel_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>flex_channel_0_0_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>flex_channel_0_0_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>flex_channel_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
